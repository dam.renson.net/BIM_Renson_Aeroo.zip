Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: 0001
Time: 2024-09-24T09:31:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 24 09:31:24 2024 * Host: RENSON-PC64rjMe * Database: C:\Users\naniw\AppData\Local\Temp\7c93a598-1d20-4466-9f6c-6721037d76b9\8842edf5-ed5c-4318-a815-06edbbae8b7a\ifc * Database version: 5507 * Database creation date: Tue Sep 24 09:31:23 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Sep 24 09:31:23 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 24 09:31:23 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head

# IfcAirTerminal: Aeroo Square White, Renson_Aeroo Round-Square_D125_Return:Aeroo Square White:348571
In: Level 1
Type - Material: Color RGB 040-040-040, Color RAL 9010
Type - Pset_AirTerminalTypeCommon - Reference: Aeroo Square White
Type - Pset_EnvironmentalImpactIndicators - Reference: Aeroo Square White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_AirTerminalTypeCommon - sets with these values: 2
